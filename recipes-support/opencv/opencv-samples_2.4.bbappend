SRC_URI = "git://code.opencv.org/opencv.git;tag=2.4.2;protocol=git"

SRCREV = "${AUTOREV}"

S = "${WORKDIR}/git"

